CIRCUIT E:\MicroWind\MicroWind\Microwind\Microwind39\examples\decoder.MSK
*
* IC Technology: CMOS 90nm, 6 Metal Copper - strained SiGe - LowK
*
VDD 1 0 DC 1.20
Vclock2 82 0 DC 0 PULSE(0.00 3.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock13 83 0 DC 0 PULSE(3.00 0.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock1 84 0 DC 0 PULSE(0.00 3.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock3 85 0 DC 0 PULSE(0.00 3.00 1.95N 0.05N 0.05N 1.95N 4.00N)
Vclock21 86 0 DC 0 PULSE(0.00 3.00 1.95N 0.05N 0.05N 1.95N 4.00N)
Vclock23 87 0 DC 0 PULSE(3.00 0.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock17 88 0 DC 0 PULSE(0.00 3.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock20 89 0 DC 0 PULSE(3.00 0.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock14 90 0 DC 0 PULSE(0.00 3.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock11 91 0 DC 0 PULSE(3.00 0.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock8 92 0 DC 0 PULSE(3.00 0.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock6 93 0 DC 0 PULSE(3.00 0.00 1.95N 0.05N 0.05N 1.95N 4.00N)
Vclock24 94 0 DC 0 PULSE(3.00 0.00 1.95N 0.05N 0.05N 1.95N 4.00N)
Vclock4 95 0 DC 0 PULSE(0.00 3.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock7 96 0 DC 0 PULSE(0.00 3.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock5 97 0 DC 0 PULSE(0.00 3.00 0.95N 0.05N 0.05N 0.95N 2.00N)
Vclock19 98 0 DC 0 PULSE(3.00 0.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock9 99 0 DC 0 PULSE(0.00 3.00 1.95N 0.05N 0.05N 1.95N 4.00N)
Vclock18 100 0 DC 0 PULSE(3.00 0.00 1.95N 0.05N 0.05N 1.95N 4.00N)
Vclock10 101 0 DC 0 PULSE(0.00 3.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock16 102 0 DC 0 PULSE(3.00 0.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock22 103 0 DC 0 PULSE(3.00 0.00 0.45N 0.05N 0.05N 0.45N 1.00N)
Vclock15 104 0 DC 0 PULSE(0.00 3.00 1.95N 0.05N 0.05N 1.95N 4.00N)
Vclock12 105 0 DC 0 PULSE(3.00 0.00 1.95N 0.05N 0.05N 1.95N 4.00N)
*
* List of nodes
* "s8" corresponds to n°19
* "s7" corresponds to n°23
* "s6" corresponds to n°28
* "s5" corresponds to n°31
* "s4" corresponds to n°35
* "s3" corresponds to n°39
* "s2" corresponds to n°44
* "s1" corresponds to n°48
* "clock2" corresponds to n°82
* "clock13" corresponds to n°83
* "clock1" corresponds to n°84
* "clock3" corresponds to n°85
* "clock21" corresponds to n°86
* "clock23" corresponds to n°87
* "clock17" corresponds to n°88
* "clock20" corresponds to n°89
* "clock14" corresponds to n°90
* "clock11" corresponds to n°91
* "clock8" corresponds to n°92
* "clock6" corresponds to n°93
* "clock24" corresponds to n°94
* "clock4" corresponds to n°95
* "clock7" corresponds to n°96
* "clock5" corresponds to n°97
* "clock19" corresponds to n°98
* "clock9" corresponds to n°99
* "clock18" corresponds to n°100
* "clock10" corresponds to n°101
* "clock16" corresponds to n°102
* "clock22" corresponds to n°103
* "clock15" corresponds to n°104
* "clock12" corresponds to n°105
*
* MOS devices
MN1 51 94 0 0 N1  W= 0.50U L= 0.10U
MN2 0 18 19 0 N1  W= 0.50U L= 0.10U
MN3 53 87 51 0 N1  W= 0.50U L= 0.10U
MN4 18 103 53 0 N1  W= 0.50U L= 0.10U
MN5 55 86 0 0 N1  W= 0.50U L= 0.10U
MN6 0 22 23 0 N1  W= 0.50U L= 0.10U
MN7 57 89 55 0 N1  W= 0.50U L= 0.10U
MN8 22 98 57 0 N1  W= 0.50U L= 0.10U
MN9 59 100 0 0 N1  W= 0.50U L= 0.10U
MN10 61 88 59 0 N1  W= 0.50U L= 0.10U
MN11 0 26 28 0 N1  W= 0.50U L= 0.10U
MN12 26 102 61 0 N1  W= 0.50U L= 0.10U
MN13 63 104 0 0 N1  W= 0.50U L= 0.10U
MN14 0 30 31 0 N1  W= 0.50U L= 0.10U
MN15 65 90 63 0 N1  W= 0.50U L= 0.10U
MN16 30 83 65 0 N1  W= 0.50U L= 0.10U
MN17 67 105 0 0 N1  W= 0.50U L= 0.10U
MN18 0 34 35 0 N1  W= 0.50U L= 0.10U
MN19 69 91 67 0 N1  W= 0.50U L= 0.10U
MN20 34 101 69 0 N1  W= 0.50U L= 0.10U
MN21 71 99 0 0 N1  W= 0.50U L= 0.10U
MN22 0 38 39 0 N1  W= 0.50U L= 0.10U
MN23 73 92 71 0 N1  W= 0.50U L= 0.10U
MN24 38 96 73 0 N1  W= 0.50U L= 0.10U
MN25 75 93 0 0 N1  W= 0.50U L= 0.10U
MN26 76 97 75 0 N1  W= 0.50U L= 0.10U
MN27 0 42 44 0 N1  W= 0.50U L= 0.10U
MN28 42 95 76 0 N1  W= 0.50U L= 0.10U
MN29 79 85 0 0 N1  W= 0.50U L= 0.10U
MN30 80 82 79 0 N1  W= 0.50U L= 0.10U
MN31 0 46 48 0 N1  W= 0.50U L= 0.10U
MN32 46 84 80 0 N1  W= 0.50U L= 0.10U
MP1 1 94 18 1 P1  W= 0.50U L= 0.10U
MP2 1 18 19 1 P1  W= 0.50U L= 0.10U
MP3 18 87 1 1 P1  W= 0.50U L= 0.10U
MP4 1 103 18 1 P1  W= 0.50U L= 0.10U
MP5 1 86 22 1 P1  W= 0.50U L= 0.10U
MP6 1 22 23 1 P1  W= 0.50U L= 0.10U
MP7 22 89 1 1 P1  W= 0.50U L= 0.10U
MP8 1 98 22 1 P1  W= 0.50U L= 0.10U
MP9 1 100 26 1 P1  W= 0.50U L= 0.10U
MP10 26 88 1 1 P1  W= 0.50U L= 0.10U
MP11 1 26 28 1 P1  W= 0.50U L= 0.10U
MP12 1 102 26 1 P1  W= 0.50U L= 0.10U
MP13 1 104 30 1 P1  W= 0.50U L= 0.10U
MP14 1 30 31 1 P1  W= 0.50U L= 0.10U
MP15 30 90 1 1 P1  W= 0.50U L= 0.10U
MP16 1 83 30 1 P1  W= 0.50U L= 0.10U
MP17 1 105 34 1 P1  W= 0.50U L= 0.10U
MP18 1 34 35 1 P1  W= 0.50U L= 0.10U
MP19 34 91 1 1 P1  W= 0.50U L= 0.10U
MP20 1 101 34 1 P1  W= 0.50U L= 0.10U
MP21 1 99 38 1 P1  W= 0.50U L= 0.10U
MP22 1 38 39 1 P1  W= 0.50U L= 0.10U
MP23 38 92 1 1 P1  W= 0.50U L= 0.10U
MP24 1 96 38 1 P1  W= 0.50U L= 0.10U
MP25 1 93 42 1 P1  W= 0.50U L= 0.10U
MP26 42 97 1 1 P1  W= 0.50U L= 0.10U
MP27 1 42 44 1 P1  W= 0.50U L= 0.10U
MP28 1 95 42 1 P1  W= 0.50U L= 0.10U
MP29 1 85 46 1 P1  W= 0.50U L= 0.10U
MP30 46 82 1 1 P1  W= 0.50U L= 0.10U
MP31 1 46 48 1 P1  W= 0.50U L= 0.10U
MP32 1 84 46 1 P1  W= 0.50U L= 0.10U
*
C2 1 0  0.660fF
C3 1 0  0.660fF
C4 1 0  0.660fF
C5 1 0  0.660fF
C6 1 0  0.660fF
C7 1 0  0.660fF
C8 1 0  0.660fF
C9 1 0  0.660fF
C10 1 0  0.385fF
C11 1 0  0.385fF
C12 1 0  0.385fF
C13 1 0  0.385fF
C14 1 0  0.385fF
C15 1 0  0.385fF
C16 1 0  0.385fF
C17 1 0  0.385fF
C18 18 0  1.608fF
C19 19 0  0.485fF
C20 1 0  0.699fF
C21 1 0  0.288fF
C22 22 0  1.685fF
C23 23 0  0.485fF
C24 1 0  0.693fF
C25 1 0  0.284fF
C26 26 0  1.638fF
C27 1 0  0.699fF
C28 28 0  0.485fF
C29 1 0  0.293fF
C30 30 0  1.657fF
C31 31 0  0.485fF
C32 1 0  0.693fF
C33 1 0  0.288fF
C34 34 0  1.495fF
C35 35 0  0.485fF
C36 1 0  0.699fF
C37 1 0  0.284fF
C38 38 0  1.516fF
C39 39 0  0.480fF
C40 1 0  0.693fF
C41 1 0  0.279fF
C42 42 0  1.507fF
C43 1 0  0.699fF
C44 44 0  0.480fF
C45 1 0  0.284fF
C46 46 0  1.488fF
C47 1 0  0.693fF
C48 48 0  0.480fF
C49 1 0  0.279fF
C51 51 0  0.231fF
C53 53 0  0.231fF
C55 55 0  0.231fF
C57 57 0  0.231fF
C59 59 0  0.231fF
C61 61 0  0.231fF
C63 63 0  0.231fF
C65 65 0  0.231fF
C67 67 0  0.231fF
C69 69 0  0.231fF
C71 71 0  0.231fF
C73 73 0  0.231fF
C75 75 0  0.231fF
C76 76 0  0.231fF
C79 79 0  0.231fF
C80 80 0  0.231fF
C82 82 0  0.020fF
C83 83 0  0.020fF
C84 84 0  0.023fF
C85 85 0  0.024fF
C86 86 0  0.022fF
C87 87 0  0.027fF
C88 88 0  0.024fF
C89 89 0  0.026fF
C90 90 0  0.025fF
C91 91 0  0.025fF
C92 92 0  0.026fF
C93 93 0  0.023fF
C94 94 0  0.020fF
C95 95 0  0.020fF
C96 96 0  0.020fF
C97 97 0  0.020fF
C98 98 0  0.020fF
C99 99 0  0.020fF
C100 100 0  0.020fF
C101 101 0  0.020fF
C102 102 0  0.020fF
C103 103 0  0.020fF
C104 104 0  0.020fF
C105 105 0  0.020fF
*
*
* n-MOS BSIM4 :
* low leakage
.MODEL N1 NMOS LEVEL=14 VTHO=0.28 U0=0.060 TOXE= 1.2E-9 LINT=0.015U
+K1 =0.450 K2=0.100 DVT0=2.300
+DVT1=0.570 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  0.9 U0=0.060 UA=3.400e-15
+WINT=0.005U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=1.100
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* p-MOS BSIM4:
* low leakage
.MODEL P1 PMOS LEVEL=14 VTHO=-0.32 U0=0.027 TOXE= 1.2E-9 LINT=0.015U
+K1 =0.450 K2=0.100 DVT0=2.300
+DVT1=0.570 LPE0=23.000e-9 ETA0=0.080
+NFACTOR=  1.9 U0=0.027 UA=2.200e-15
+WINT=0.005U LPE0=23.000e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=0.700
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 5.00N
print  V(82) V(85) V(48) V(39) V(44) V(19) V(23) V(28) V(31) V(35) > out.txt
plot  V(82) V(85) V(48) V(39) V(44) V(19) V(23) V(28) V(31) V(35)
.endc
.END
